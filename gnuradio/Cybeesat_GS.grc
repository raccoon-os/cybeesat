options:
  parameters:
    author: jdiez
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: cybee_gs
    output_language: python
    title: cybee_gs
  states: {}

blocks:
- name: Doppler
  id: variable_qtgui_label
  parameters:
    label: Doppler TX
    type: int
    value: doppler_shift_tx
  states: {}
- name: Doppler_RX
  id: variable_qtgui_label
  parameters:
    label: Doppler RX
    type: int
    value: doppler_shift_rx
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: current_timestamp
  id: variable
  parameters:
    value: datetime.utcnow().strftime("%Y.%m.%d.%H.%M.%S") + "UTC"
  states: {}
- name: demod_samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: doppler_corrected_rx_freq
  id: variable
  parameters:
    value: '145925000'
  states: {}
- name: doppler_corrected_tx_freq
  id: variable
  parameters:
    value: '145925380'
  states: {}
- name: doppler_shift_rx
  id: variable
  parameters:
    value: doppler_corrected_rx_freq-tctm_freq
  states: {}
- name: doppler_shift_tx
  id: variable
  parameters:
    value: doppler_corrected_tx_freq-tctm_freq
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '700'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.77'
  states: {}
- name: high_bound
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: low_bound
  id: variable
  parameters:
    value: '-0.45'
  states: {}
- name: mid
  id: variable
  parameters:
    value: (low_bound+high_bound)/2
  states: {}
- name: norm
  id: variable
  parameters:
    value: (high_bound-low_bound)/2
  states: {}
- name: preamble_bits
  id: variable
  parameters:
    value: '''''.join(f"{b:08b}" for b in preamble_bytes)'
  states: {}
- name: preamble_bytes
  id: variable
  parameters:
    value: bytes([0x34, 0xd3]) + b"YH1SUP"
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: tctm_freq
  id: variable
  parameters:
    value: '145925000'
  states: {}
- name: tune_offset
  id: variable
  parameters:
    value: '-125100'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demod_samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '100'
    gain: '1'
    high_cutoff_freq: '1000'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: int(samp_rate/15000)
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-mid'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt.raw
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/ground_station_rx_" + current_timestamp + ".15ksps.cf32"'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tune_offset-doppler_shift_rx
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: '-tune_offset+doppler_shift_tx'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/norm
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '10'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: demod_samp_rate/baudrate
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "from gnuradio import gr\nimport pmt\n\nclass pdu_prepend_preamble(gr.basic_block):\n    def __init__(self, callsign: bytes = b\"DZ9XYZ\", tx_vcom: int = 0, rx_vcom: int = 0):\n        gr.basic_block.__init__(self,\n            name=\"PDU Preamble\",\n            in_sig=[],\n            out_sig=[])\n\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_pdu)\n\n        assert(len(callsign) == 6)\n        assert(tx_vcom in [0, 1])\n        assert(rx_vcom in [0, 1])\n\n        self.preamble = bytes([0x55]*16) + bytes([0x34, 0xd3]) + callsign + bytes([tx_vcom, rx_vcom])\n\n    def handle_pdu(self, pdu):\n        meta = pmt.car(pdu)\n        data = pmt.cdr(pdu)\n\n        payload = bytes(pmt.u8vector_elements(data))\n        full_payload = self.preamble + payload + bytes([0xaa]*8)\n\n        out_pdu = pmt.cons(meta, pmt.init_u8vector(len(full_payload), list(full_payload)))\n        self.message_port_pub(pmt.intern(\"out\"), out_pdu)\n        print(\"added preamble!\")\n\n\n"
    callsign: b"DZ9XYZ"
    rx_vcom: '0'
    tx_vcom: '0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\nimport numpy as np\n\nclass blk(gr.basic_block):\n    \"\"\"\n    \"\"\"\n    def __init__(self):\n        gr.basic_block.__init__(self,\n            name=\"Preamble Detector to PDU\",\n            in_sig=[np.uint8],\n            out_sig=[])\n\n        # Message-Port-Ausgang\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        # Preamble definieren (Bitstring aus 13 Bytes)\n        preamble_bytes = bytes([0xaa]*6 + [0x34, 0xd3])\n        self.preamble_bits = ''.join(f\"{b:08b}\" for b in preamble_bytes)\n\n        # interner Bitpuffer\n        self.bit_buffer = \"\"\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        # Bytes (0x00 oder 0x01) → Bitstring\n        self.bit_buffer += ''.join(str(int(b)) for b in in0)\n\n        while True:\n            preamble_index = self.bit_buffer.find(self.preamble_bits)\n            if preamble_index == -1:\n                break  # keine Preamble gefunden\n\n            start = preamble_index + len(self.preamble_bits)\n            callsign_bits = 8 * 6 # 6 bytes callsign\n            payload_bits = 8 * 255  # 255 Bytes Payload\n            bits_needed = callsign_bits + payload_bits\n\n            if len(self.bit_buffer) < start + bits_needed:\n                break  \n\n            # Payload-Bits extrahieren\n            payload_bits = self.bit_buffer[start+callsign_bits:start+callsign_bits+payload_bits]\n            payload_bytes = [int(payload_bits[i:i+8], 2) for i in range(0, len(payload_bits), 8)]\n\n            # Debug-Ausgabe\n            #print(\" Payload received:\", payload_bytes)\n\n            # Public PDU\n            pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(payload_bytes), payload_bytes))\n            self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n            # Alles bis hinter dieses Paket aus dem Buffer löschen\n            self.bit_buffer = self.bit_buffer[start + bits_needed:]\n            break  # nur eine PDU pro Call erzeugen\n\n        self.consume(0, len(in0))\n        return 0\n\n"
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler_corrected_tx_freq
  states: {}
- name: gpredict_MsgPairToVar_1
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler_corrected_rx_freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '10056'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '10066'
    type: UDP_CLIENT
  states: {state: disabled}
- name: network_socket_pdu_1_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '10066'
    type: UDP_CLIENT
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '12000'
    fc: '0'
    fftsize: '1024'
    type: complex
    ymin: '-180'
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: '12000'
    fc: '10000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: demod_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '10'
    sync: preamble_bits
    threshold: '15'
  states: {}
- name: testhier_0
  id: testhier
  parameters:
    samp_rate: '1'
    sample_rate_tx: int(1.2e6)
    sps: '10'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tctm_freq+tune_offset
    gain0: gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: tctm_freq+tune_offset
    dc_offs_enb0: auto
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: pkt_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_add_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [band_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [band_pass_filter_1, '0', blocks_file_sink_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_freqshift_cc_0, '0', band_pass_filter_0, '0']
- [blocks_freqshift_cc_0, '0', band_pass_filter_1, '0']
- [blocks_freqshift_cc_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_freqshift_cc_0, '0']
- [dc_blocker_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_1, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_gmsk_mod_0, '0', testhier_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_1, out, blocks_message_debug_2, print]
- [epy_block_1, out, network_socket_pdu_1, pdus]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_1, inpair]
- [gpredict_doppler_0, tx_freq, gpredict_MsgPairToVar_0, inpair]
- [network_socket_pdu_0, pdus, epy_block_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [satellites_sync_to_pdu_packed_0, out, blocks_message_debug_2_0, print]
- [satellites_sync_to_pdu_packed_0, out, network_socket_pdu_1_0, pdus]
- [testhier_0, '0', blocks_freqshift_cc_1, '0']
- [testhier_0, '0', qtgui_freq_sink_x_0, '0']
- [testhier_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', band_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-978-g90d26cbb
