options:
  parameters:
    generate_options: hb
    id: testhier
    output_language: python
    title: Resampler
  states: {}

blocks:
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '100'
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 8*sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Tag Block',\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        self.tag_added = False\n        self.last_packet_len_tag = None\n\n    def work(self, input_items, output_items):\n        # Get all tags in the current window\n        tags = self.get_tags_in_window(0, 0, len(input_items[0]))\n        \n        # Check for packet_len tag\n        new_packet_len_tag = None\n        for tag in tags:\n            if tag.key == pmt.intern(\"packet_len\"):\n                print(\"got len tag\", tag)\n                new_packet_len_tag = tag\n                break\n\n        # If a new packet_len tag is found, reset tag_added\n        if new_packet_len_tag and new_packet_len_tag != self.last_packet_len_tag:\n            self.tag_added = False\n            self.last_packet_len_tag = new_packet_len_tag\n            print(\"len tag reset\")\n\n        if not self.tag_added and len(input_items[0]) > 0:\n            # Get the current time\n            current_time = time.time()\n            seconds = int(current_time)\n            fractional_seconds = current_time - seconds\n            \n            key = pmt.intern(\"tx_time\")\n            value = pmt.make_tuple(pmt.from_uint64(seconds), pmt.from_double(fractional_seconds))\n            self.add_item_tag(\n                0,  # Output port 0\n                self.nitems_written(0),  # Index of the first sample in absolute terms\n                key,  # Key of the tag\n                value  # Value of the tag\n            )\n            self.tag_added = True\n            print(\"added tx time tag\")\n        \n        output_items[0][:] = input_items[0]  # Copy input to output\n        return len(output_items[0])\n\n\n\n"
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: '100'
    type: ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate Demod
    value: '1'
  states: {}
- name: sample_rate_tx
  id: parameter
  parameters:
    label: Sample Rate (Transmit)
    value: int(1.2e6)
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    value: '10'
  states: {}

connections:
- [blocks_tagged_stream_multiply_length_0, '0', epy_block_4, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pad_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0, '0', pfb_arb_resampler_xxx_0, '0']
- [epy_block_4, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_tagged_stream_multiply_length_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
